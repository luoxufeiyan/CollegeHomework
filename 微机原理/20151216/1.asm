DATAS SEGMENT
    VAR1 DB 46H
    VAR2 DB 15H
    VAR3 DB 0A2H
DATAS ENDS

STACKS SEGMENT
    DW 100H DUP(?)

STACKS ENDS

CODES SEGMENT
    ASSUME CS:CODES,DS:DATAS,SS:STACKS
START:
    MOV AX,DATAS
    MOV DS,AX
    MOV ES,AX
    MOV AX,STACKS 
    MOV SS,AX
    LEA SP,TOP
    MOV AL,VAR1
    CMP AL,VAR2
    JAE NO_CHG1
    XCHG AL,VAR2
NO_CHG1:
    CMP AL,VAR3
    JAE NO_CHG2
    XCHG AL,VAR3
NO_CHG2:
    MOV VAR1,AL
    MOV AL,VAR2
    CMP AL,VAR3
    JAE NO_CHG3
    XCHG AL,VAR3
    MOV VAR2,AL
    INT 21H
NO_CHG3:
    MOV AL,VAR1
    CALL DISPAL
    MOV AL,VAR2
    CALL DISPAL
    MOV AL,VAR3
    CALL DISPAL
    MOV AH,4CH
    INT 21H
DISPAL PROC NEAR
    PUSH AX
    PUSH CX
    PUSH DX
    PUSH AX
    MOV CL,4
    SHR AL,CL
    CALL CHANG
    MOV AH,02
    MOV DL,AL
    INT 21H
    POP AX
    AND AL,0FH
    CALL CHANG
    MOV AH,02
    MOV DL,AL
    INT 21H
    POP DX
    POP CX
    POP AX
    RET 
DISPAL ENDP
CHANG PROC NEAR
    CMP AL,10
    JNGE CHANG1
    ADD AL,7
CHANG1:
    ADD AL,30H
    RET
CHANG ENDP
CODES ENDS
    END START
